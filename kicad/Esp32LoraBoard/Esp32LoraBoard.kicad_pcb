# Repository vrees/water-level-meter-espidf

File README.md:

# water-level-meter
Measure the water level in Viktor's spring tank using ESP32 espidf Framework

### Links:
* Board: https://github.com/LilyGO/TTGO-LORA32
* https://github.com/manuelbl/ttn-esp32
* https://github.com/bertrik/LoraWanPmSensor/blob/master/Esp32PmSensor/Esp32PmSensor.ino
* Display Library u8g2: https://github.com/olikraus/u8g2/wiki

## KiCad design kicad/Esp32LoraBoard/Esp32LoraBoard.kicad_pcb

Parts:
AE1: Antenna_Shield; SMA_Samtec_SMA-J-P-H-ST-EM1_EdgeMount
BT1: LiFePo-Batterie; PhoenixContact_MSTBVA_2,5_2-G-5,08_1x02_P5.08mm_Vertical
C1, C4, C5, C7, C8: 100n; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C2: 10u; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C3, C9, C10: 1u; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C6: 1n; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
J1: USB_B_Micro; USB_Micro-B_GCT_USB3076-30-A
J2: Power-Selector; PinHeader_1x03_P2.54mm_Vertical
J3: Testpoints; PinHeader_1x05_P2.54mm_Vertical
J4: ESP_PROG_JTAG; PinHeader_2x05_P1.27mm_Vertical
J5: Prog; PinHeader_1x05_P2.54mm_Vertical
J6: ext_Measure; PhoenixContact_MSTBVA_2,5_4-G-5,08_1x04_P5.08mm_Vertical
J7: Measurement-Selector; PinHeader_1x03_P2.54mm_Vertical
J8: OLED_128x64; PinHeader_1x04_P2.54mm_Vertical
Q1: UMH3N; SOT65P230X110-6N; Manufacturer_Part_Number UMH3N
Q2, Q4, Q6: Si2302DS_NMOS; TSOT-23_HandSoldering
Q3, Q5: Si2301DS_PMOS; TSOT-23_HandSoldering
R1, R2, R3, R4, R9, R10, R11, R13, R14, R15: 10k; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R5, R6: optional; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R7, R8, R12: 100k; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
SW1: Rotary_Encoder; RotaryEncoder_Alps_EC11E-Switch_Vertical_H20mm
SW2: Reset; SW_SPST_CK_RS282G05A3
TP1: TP_U_BATT; PinHeader_1x01_P2.54mm_Vertical
TP2: TP_U_EXT; PinHeader_1x01_P2.54mm_Vertical
TP3: VCC_2; PinHeader_1x01_P2.54mm_Vertical
U1: LM3940IMP-3.3; SOT230P696X180-4N
U2: ESP32-WROOM-32
U3: RFM95W-868S2; HOPERF_RFM9XW_SMD

Connections:
+3V3: C2.1, J2.3, J3.3, U1.3 (OUT)
/Boot: C6.2, Q1.3 (C2), R2.2, U2.25 (IO0)
/CS: U2.30 (IO18), U3.5 (NSS)
/DTR: J5.5, Q1.1 (E1), Q1.5 (B2)
/IO1: U2.9 (IO33), U3.15 (DIO1)
/IO2: U2.8 (IO32), U3.16 (DIO2)
/IRQ: U2.11 (IO26), U3.14 (DIO0)
/MISO: U2.31 (IO19), U3.2 (MISO)
/MOSI: U2.12 (IO27), U3.3 (MOSI)
/POWER_ENABLE: Q5.1 (G), R12.2, U2.27 (IO16)
/ROT_A: C9.1, R14.2, SW1.A, U2.4 (SENSOR_VP)
/ROT_B: C10.1, R15.2, SW1.B, U2.5 (SENSOR_VN)
/ROT_SW: SW1.S1, U2.28 (IO17)
/RST: U2.37 (IO23), U3.6 (RESET)
/RTS: J5.2, Q1.2 (B1), Q1.4 (E2)
/RX: J5.4, U2.34 (RXD0/IO3)
/Reset: C5.1, Q1.6 (C1), R1.2, SW2.2, U2.3 (EN)
/SCK: U2.29 (IO5), U3.4 (SCK)
/SCL: Q6.3 (D), R13.2, U2.36 (IO22)
/SCL_2: J8.3, Q6.2 (S), R11.2
/SDA: Q4.3 (D), R10.2, U2.33 (IO21)
/SDA_2: J8.4, Q4.2 (S), R9.2
/TCK: J4.4, U2.16 (IO13)
/TDI: J4.8, U2.14 (IO12)
/TDO: J4.6, U2.23 (IO15)
/TMS: J4.2, U2.13 (IO14)
/TX: J5.3, U2.35 (TXD0/IO1)
/UBAT_ENABLE: Q3.1 (G), R8.2, U2.10 (IO25)
/UBAT_MEASURE: R3.2, R4.1, TP1.1, U2.6 (IO34)
/U_EXT_ENABLE: Q2.1 (G), R7.1, TP2.1, U2.26 (IO4)
/U_EXT_MEASURE: J6.2, R5.2, R6.1, U2.7 (IO35)
/V-Batt: BT1.1 (+), J2.1, J3.2
/VCC_2: C8.1, J3.5, J8.2, Q4.1 (G), Q5.2 (S), Q6.1 (G), R9.1, R11.1, R14.1, R15.1, TP3.1
/ext.Voltage: J6.4, J7.1
GND: AE1.2 (Shield), BT1.2 (-), C1.2, C2.2, C3.2, C4.2, C5.2, C6.1, C7.1, C8.2, C9.2, C10.2, J1.5 (GND), J3.1, J4.3, J4.5, J4.7, J4.9, J5.1, J8.1, Q2.2 (S), R4.2, R7.2, SW1.C, SW1.S2, SW2.1, U1.2 (GND_2), U1.4 (GND), U2.1 (GND), U2.15 (GND), U2.38 (GND), U3.1 (GND), U3.8 (GND), U3.10 (GND)
unnamed: AE1.1 (A), U3.9 (ANT)
unnamed: C1.1, J1.1 (VBUS), U1.1 (IN)
unnamed: J6.1, Q2.3 (D), R6.2
unnamed: J6.3, J7.2, R5.1
unnamed: Q3.2 (S), R3.1
VCC: C3.1, C4.1, C7.2, J2.2, J3.4, J7.3, Q3.3 (D), Q5.3 (D), R1.1, R2.1, R8.1, R10.1, R12.1, R13.1, U2.2 (VDD), U3.13 (3.3V)

Notes on the sheet:
SCK 5 CS 18 MISO 19 MOSI 27 RST 23 IRQ 26 IO1 33 IO2 32
DTR
RTS
GND
Lora Pins
OLED Display via Levelshifter connected to I2C bus
Pripherie can be switched off
Voltage Measurement (internal and external)
Optional Power Supply

Board: 2 copper layers, 71.8 x 64.1 mm, 49 parts (0 on the bottom side), 41 nets.

## Commit log

2020-02-24 initial load. Joining worked
2020-02-24 added README
2020-02-24 err-problem
2020-02-24 debug
2020-02-24 fixed spi problem
2020-02-24 display
2020-02-24 display and voltage added
2020-02-24 still problem with display
2020-02-25 adc.h added
2020-02-25 added ulp logic
2020-03-22 KiCad
2020-03-25 Diagram approved
2020-03-29 schema version 1.0 done
2020-04-11 Reset Button added
2020-04-19 Kicad Version V1.1
2020-04-21 Reset Circuit modified. C5 = 100nF now in order to enter programming mode after reset
2020-04-21 exchanged RX/TX and Boot/Reset wires
2020-05-02 created separate files
2020-05-25 moved Kicad to separate project
